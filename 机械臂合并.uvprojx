# Keil uVision project 机械臂合并.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 机械臂合并 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\System\Delay;.\System\sys;.\System\Usart;.\Hardware\LED;.\Hardware\ULTRASONIC;.\Hardware\SERVO;.\Hardware\TIM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/ULTRASONIC/: ultrasonic.c
    ./Hardware/SERVO/: servo.c
    ./Hardware/TIM/: tim.c
  group System
    ./System/Delay/: delay.c
    ./System/sys/: sys.c
    ./System/Usart/: usart.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
